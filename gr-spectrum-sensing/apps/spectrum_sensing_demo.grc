<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>1000</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>2048</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>window.blackmanharris(1024)</value></param>
<param><key>shift</key><value>False</value></param>
</block>
<block>
<key>howto_spectrum_sensing_cf</key>
<param><key>id</key><value>howto_spectrum_sensing_cf_0</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>ninput_samples</key><value>2048</value></param>
<param><key>samples_per_band</key><value>16</value></param>
<param><key>pfd</key><value>0.001</value></param>
<param><key>pfa</key><value>0.0001</value></param>
<param><key>tcme</key><value>1.9528</value></param>
<param><key>output_far</key><value>True</value></param>
<param><key>band_location</key><value>0</value></param>
<param><key>nsegs_to_check</key><value>6</value></param>
<param><key>debug_stats</key><value>True</value></param>
<param><key>debug_histogram</key><value>False</value></param>
<param><key>useless_band</key><value>200000.0</value></param>
<param><key>nframes_to_check</key><value>3</value></param>
<param><key>nframes_to_average</key><value>4</value></param>
<param><key>downconverter</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>howto_spectrum_sensing_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>howto_spectrum_sensing_cf_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
